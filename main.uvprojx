# Keil uVision project main.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: main +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\PAC9685;.\systick;.\gait;..\..\FreeRTOS\include;..\..\FreeRTOS\portable\RVDS\ARM_CM4F;.\JDY-31;.\ATTITUDE;.\MPU6050;.\USART;.\balance
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: main.c
  group PAC9685
    ./PAC9685/: pac.c iic.c
  group systick
    ./systick/: systick.c
  group gait
    ./gait/: gait.c
  group FreeRTOS_CORE
    ../../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../../FreeRTOS/portable/MemMang/: heap_4.c
  group JDY-31
    ./JDY-31/: bluetooth.c
  group ATTITUDE
    ./ATTITUDE/: attitude.c
  group USART
    ../../SYSTEM/USART/: usart.c
  group MPU6050
    ./MPU6050/: mpu6050.c
  group BALANCE
    ./balance/: balance.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.3.1, Device:StdPeriph Drivers:Framework 1.3.1, Device:StdPeriph Drivers:GPIO 1.3.0, Device:StdPeriph Drivers:I2C 1.3.0, Device:StdPeriph Drivers:PWR 1.3.0, Device:StdPeriph Drivers:RCC 1.3.0, Device:StdPeriph Drivers:TIM 1.3.0, Device:StdPeriph Drivers:USART 1.3.0
